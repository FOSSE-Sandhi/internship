<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>gr_null_sink</key>
<param><key>id</key><value>gr_null_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>nyquist_block_nyquist</key>
<param><key>id</key><value>nyquist_block_nyquist_0</value></param>
<param><key>a</key><value>0,1,2*0.9*10,100</value></param>
<param><key>b</key><value>0,1,2*0.3*10.1,102.01</value></param>
<param><key>c</key><value>0,1,2*0.1*15.1,228.01</value></param>
<param><key>d</key><value>0,1,2*0.9*15,225</value></param>
</block>
<block>
<key>gr_null_source</key>
<param><key>id</key><value>gr_null_source_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<connection><source_block_id>gr_null_source_0</source_block_id><sink_block_id>nyquist_block_nyquist_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nyquist_block_nyquist_0</source_block_id><sink_block_id>gr_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
